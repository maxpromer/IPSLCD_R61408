# Keil uVision project Camera and uc_gui_2.0.uvprojx, settings and files
target Tiky Camera with ucgui and GPS (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tiky +hex
  c flags: oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\code\header;..\code\library\inc;..\..\include;..\..\..\..\library\inc;..\..\..\..\..\FWLib\library\inc;..\code\FAT16;..\code\driver;..\code\ffs;..\code\TFT;..\code\OV7670;..\code\TFT;..\code\menu;..\code\TFT\TFT_ILI9328;..\code\RTC;..\code\user;..\code\GUI\Config;..\code\ADC;..\FWlib\inc;..\code\GUI\GUI_inc;..\code\GPS;..\code\GUI_4.04\Include;..\code\PS2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group system
    ../code/system/: stm32f10x_it.c
    ../CMSIS/: core_cm3.c system_stm32f10x.c
    ../CMSIS/startup/: startup_stm32f10x_md.s
  group ADC
    ../code/ADC/: ADC.C
  group user
    ../code/user/: main.c serialnum.c Font_lib_SD.c ucGUI_Practice.c
    ../code/GUI/: GUI_X.c
  group Test ucGUI
    ../code/library/: Camera_uCGUI Lib.lib
    ../code/Test ucGUI/: Dialog_All.c DIALOG_SliderColor.c WM_LateClipping.c DIALOG_NestedModal.c WIDGET_Effect.c WIDGET_NumPad.c WIDGET_Multipage.c WIDGET_ButtonRound.c
  group GPS
    ../code/GPS/: GPS_tiky.c
  group FATFS
    ../code/ffs/: ff.c diskio.c My_FF.c
  group OV7670
    ../code/OV7670/: delay.c delay.h fifo.c fifo.h ov7670.c ov7670.h OV7670_test.c ov7670config.h sccb.c sccb.h
  group menu
    ../code/menu/: my_menu.c
  group RTC
    ../code/RTC/: RTC.c calendar.c
  group TFT
    ../code/TFT/TFT_ILI9328/: ILI9325.c
    ../code/TFT/: picdemo.c lcm_api.c touch.c
  group driver
    ../code/driver/: msd.c SysConfig.c uart.c
  group FWLib
    ../FWlib/src/: stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_bkp.c misc.c stm32f10x_pwr.c stm32f10x_fsmc.c
  group LCDDriver
    ../code/GUI/LCDDriver/: LCDNull.c
  group PS2
    ../code/PS2/: mouse.c ps2.c
